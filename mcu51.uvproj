# Keil uVision project mcu51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mcu51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\Uart;.\IIC;.\OLED;.\DHT11
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Delay/: delay.c
    ./Uart/: uart.c
    ./IIC/: iic.c
    ./OLED/: oled.c
    ./DHT11/: dht11.c
